# Keil uVision project 2_5KW_PFC.uvprojx, settings and files
target Code (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: 2_5KW_PFC +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: ..\App;..\Core;..\Libraries\inc;..\Libraries\src;..\Libraries\inc\reg;..\Libraries\Include
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fff4000 size 0xc000
  scatter file: ..\Output\3_3KW_SPC1168.sct
  group APP
    ../App/: AdcFunction.c ChargeFunction.c delay.c isr.c main.c SystemConfig.c system_spc1168.c GlobalDefine.h fsm.c algorithm.c retarget.c UART_Debug.c
  group Core
    ../Core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_spc1168.s
  group LIB
    ../Libraries/src/: adc.c clock.c flash.c gpio.c pwm.c system.c timer.c aes.c comp.c crc.c ecap.c i2c.c pga.c power.c ssp.c uart.c wdt.c
  group DSP_lib
    ../Libraries/: arm_cortexM4lf_math.lib
